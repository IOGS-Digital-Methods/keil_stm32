# Keil uVision project hello-mdk.uvprojx, settings and files
target hello-mdk (6220000::V6.22::ARMCLANG)
  device: STM32G431KBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello-mdk
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=2
  c define: TOOLCHAIN_ARM_STD DEVICE_SERIAL_FC=1 DEVICE_SERIAL_ASYNCH=1 DEVICE_RESET_REASON=1 DEVICE_CAN=1 DEVICE_SLEEP=1 DEVICE_ANALOGOUT=1 DEVICE_SERIAL=1 DEVICE_FLASH=1 MBED_TICKLESS DEVICE_WATCHDOG=1 DEVICE_SPISLAVE=1 DEVICE_PORTINOUT=1 USE_FULL_LL_DRIVER DEVICE_RTC=1 TARGET_STM32G4 USE_HAL_DRIVER TARGET_MCU_STM32G4 DEVICE_SPI_ASYNCH=1 DEVICE_PORTOUT=1 MBED_TRAP_ERRORS_ENABLED=1 TARGET_RTOS_M4_M7 TARGET_CORTEX DEVICE_I2CSLAVE=1 __MBED_CMSIS_RTOS_CM MBED_BUILD_TIMESTAMP=1737899097.188496 TARGET_STM32G431xB DEVICE_PORTIN=1 DEVICE_USTICKER=1 DEVICE_I2C_ASYNCH=1 DEVICE_INTERRUPTIN=1 DEVICE_PWMOUT=1 EXTRA_IDLE_STACK_REQUIRED TARGET_STM TOOLCHAIN_ARM DEVICE_MPU=1 MBED_DEBUG TARGET_M4 TRANSACTION_QUEUE_SIZE_SPI=2 __CMSIS_RTOS ARM_MATH_CM4 __MBED__=1 MBED_MINIMAL_PRINTF TARGET_LIKE_CORTEX_M4 TARGET_MCU_STM32 TARGET_NUCLEO_G431KB __FPU_PRESENT=1 DEVICE_TRNG=1 DEVICE_LPTICKER=1 TARGET_CORTEX_M STM32G431xx DEVICE_STDIO_MESSAGES=1 COMPONENT_FLASHIAP=1 TARGET_NAME=NUCLEO_G431KB DEVICE_ANALOGIN=1 DEVICE_SPI=1 TARGET_LIKE_MBED DEVICE_I2C=1 TARGET_RELEASE __CORTEX_M4 TOOLCHAIN_ARMC6 MULADDC_CANNOT_USE_R7
  c misc: -g -fno-rtti -fno-c++-static-destructors -Wno-reserved-user-defined-literal -fshort-wchar -Wno-armcc-pragma-anon-unions --target=arm-arm-none-eabi -mcpu=cortex-m4 -Wno-armcc-pragma-push-pop -fdata-sections -mfpu=fpv4-sp-d16 -mfloat-abi=hard -Wno-deprecated-register -fshort-enums -fno-exceptions -mthumb -c -include ./mbed_config.h
  c include: .;mbed-os;mbed-os/cmsis;mbed-os/cmsis/CMSIS_5;mbed-os/cmsis/CMSIS_5/CMSIS;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2;mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M;mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include;mbed-os/cmsis/device;mbed-os/cmsis/device/RTE;mbed-os/cmsis/device/RTE/include;mbed-os/cmsis/device/rtos;mbed-os/connectivity;mbed-os/connectivity/cellular;mbed-os/connectivity/drivers;mbed-os/connectivity/drivers/802.15.4_RF;mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver;mbed-os/connectivity/drivers/cellular;mbed-os/connectivity/drivers/cellular/Altair;mbed-os/connectivity/drivers/cellular/Altair/ALT1250;mbed-os/connectivity/drivers/cellular/Altair/ALT1250/PPP;mbed-os/connectivity/drivers/cellular/GEMALTO;mbed-os/connectivity/drivers/cellular/GEMALTO/CINTERION;mbed-os/connectivity/drivers/cellular/GENERIC;mbed-os/connectivity/drivers/cellular/GENERIC/GENERIC_AT3GPP;mbed-os/connectivity/drivers/cellular/MultiTech;mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano;mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano/PPP;mbed-os/connectivity/drivers/cellular/QUECTEL;mbed-os/connectivity/drivers/cellular/QUECTEL/BC95;mbed-os/connectivity/drivers/cellular/QUECTEL/BG96;mbed-os/connectivity/drivers/cellular/QUECTEL/EC2X;mbed-os/connectivity/drivers/cellular/QUECTEL/M26;mbed-os/connectivity/drivers/cellular/QUECTEL/UG96;mbed-os/connectivity/drivers/cellular/RiotMicro;mbed-os/connectivity/drivers/cellular/RiotMicro/AT;mbed-os/connectivity/drivers/cellular/TELIT;mbed-os/connectivity/drivers/cellular/TELIT/HE910;mbed-os/connectivity/drivers/cellular/TELIT/ME310;mbed-os/connectivity/drivers/cellular/TELIT/ME910;mbed-os/connectivity/drivers/cellular/UBLOX;mbed-os/connectivity/drivers/cellular/UBLOX/AT;mbed-os/connectivity/drivers/cellular/UBLOX/N2XX;mbed-os/connectivity/drivers/cellular/UBLOX/PPP;mbed-os/connectivity/drivers/emac/TARGET_STM;mbed-os/connectivity/drivers/mbedtls/TARGET_STM;mbed-os/connectivity/drivers/nfc;mbed-os/connectivity/drivers/nfc/PN512;mbed-os/connectivity/drivers/wifi;mbed-os/connectivity/drivers/wifi/esp8266-driver;mbed-os/connectivity/libraries;mbed-os/connectivity/libraries/mbed-coap;mbed-os/connectivity/libraries/nanostack-libservice;mbed-os/connectivity/libraries/ppp;mbed-os/connectivity/lorawan;mbed-os/connectivity/lwipstack;mbed-os/connectivity/mbedtls;mbed-os/connectivity/nanostack;mbed-os/connectivity/netsocket;mbed-os/connectivity/nfc;mbed-os/drivers;mbed-os/drivers/device_key;mbed-os/drivers/include;mbed-os/drivers/include/drivers;mbed-os/drivers/include/drivers/interfaces;mbed-os/drivers/usb;mbed-os/events;mbed-os/features;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/mbed-client-cli;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/utest;mbed-os/hal;mbed-os/hal/include;mbed-os/hal/include/hal;mbed-os/hal/usb;mbed-os/hal/usb/include;mbed-os/hal/usb/include/usb;mbed-os/platform;mbed-os/platform/cxxsupport;mbed-os/platform/include;mbed-os/platform/include/platform;mbed-os/platform/include/platform/internal;mbed-os/platform/mbed-trace;mbed-os/platform/mbed-trace/include;mbed-os/platform/mbed-trace/include/mbed-trace;mbed-os/platform/randlib;mbed-os/platform/source;mbed-os/platform/source/minimal-printf;mbed-os/rtos;mbed-os/rtos/include;mbed-os/rtos/include/rtos;mbed-os/rtos/include/rtos/internal;mbed-os/rtos/source;mbed-os/storage;mbed-os/storage/blockdevice;mbed-os/storage/blockdevice/COMPONENT_FLASHIAP;mbed-os/storage/blockdevice/include;mbed-os/storage/blockdevice/include/blockdevice;mbed-os/storage/blockdevice/include/blockdevice/internal;mbed-os/storage/filesystem;mbed-os/storage/kvstore;mbed-os/targets/TARGET_STM;mbed-os/targets/TARGET_STM/TARGET_STM32G4;mbed-os/targets/TARGET_STM/TARGET_STM32G4/STM32Cube_FW;mbed-os/targets/TARGET_STM/TARGET_STM32G4/STM32Cube_FW/CMSIS;mbed-os/targets/TARGET_STM/TARGET_STM32G4/STM32Cube_FW/STM32G4xx_HAL_Driver;mbed-os/targets/TARGET_STM/TARGET_STM32G4/STM32Cube_FW/STM32G4xx_HAL_Driver/Legacy;mbed-os/targets/TARGET_STM/TARGET_STM32G4/TARGET_STM32G431xB;mbed-os/targets/TARGET_STM/TARGET_STM32G4/TARGET_STM32G431xB/TARGET_NUCLEO_G431KB;D:/tools/git_repo/digital_methods/keil_stm32/mbed_test/test_from_mbed_cli/hello-mdk/mbed-os
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/TARGET_STM32G431xB/TOOLCHAIN_ARM/stm32g431xb.sct
  link misc: --predefine="-DMBED_BOOT_STACK_SIZE=4096" --predefine="-DMBED_RAM_SIZE=0x8000" --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_ROM_SIZE=0x20000" --predefine="-DMBED_RAM_START=0x20000000" --keep=os_cb_sections --predefine="-DMBED_ROM_START=0x8000000" --any_contingency --show_full_path --legacyalign --verbose --remove --cpu=Cortex-M4
  group hello-mdk
    ./: main.cpp mbed_config.h
    ./: mbed_config.h
  group mbed-os
    ./mbed-os/drivers/source/: AnalogIn.cpp AnalogOut.cpp BufferedSerial.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp DigitalIn.cpp DigitalInOut.cpp DigitalOut.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp MbedCRC.cpp OSPI.cpp PortIn.cpp PortInOut.cpp PortOut.cpp PwmOut.cpp QSPI.cpp ResetReason.cpp SerialBase.cpp SerialWireOutput.cpp SPI.cpp SPISlave.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp UnbufferedSerial.cpp Watchdog.cpp
    ./mbed-os/drivers/include/drivers/: AnalogIn.h AnalogOut.h BufferedSerial.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h FlashIAP.h HighResClock.h I2C.h I2CSlave.h InterruptIn.h LowPowerClock.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h OSPI.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawCAN.h RealTimeClock.h ResetReason.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h Ticker.h TickerDataClock.h Timeout.h Timer.h TimerEvent.h UnbufferedSerial.h Watchdog.h
    ./mbed-os/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c device.h gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_overrides.c i2c_api.c lp_ticker.c lp_ticker_defines.h mbed_crc_api.c mbed_overrides.c mbed_rtx.h nvic_addr.h ospi_api.c PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c qspi_api.c reset_reason.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_i2c_api.h stm_spi_api.c trng_api.c us_ticker.c us_ticker_defines.h USBPhy_STM32.cpp USBPhyHw.h watchdog_api.c
    ./mbed-os/hal/include/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h ospi_api.h pinmap.h PinNameAliases.h port_api.h pwmout_api.h qspi_api.h reset_reason_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h static_pinmap.h ticker_api.h trng_api.h us_ticker_api.h watchdog_api.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/: analogin_device.c analogout_device.c cmsis.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.c i2c_device.h objects.h PeripheralNames.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h us_ticker_data.h
    ./mbed-os/platform/source/: ATCmdParser.cpp CriticalSectionLock.cpp CThunkBase.cpp DeepSleepLock.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c mbed_assert.c mbed_atomic_impl.c mbed_board.c mbed_crash_data_offsets.h mbed_critical.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mem_trace.cpp mbed_mktime.c mbed_mpu_mgmt.c mbed_os_timer.cpp mbed_poll.cpp mbed_power_mgmt.c mbed_retarget.cpp mbed_rtc_time.cpp mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_thread.cpp mbed_wait_api_no_rtos.c newlib_nano_malloc_workaround.c Stream.cpp SysTimer.cpp
    ./mbed-os/platform/include/platform/: ATCmdParser.h Callback.h CircularBuffer.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_atomic.h mbed_chrono.h mbed_critical.h mbed_debug.h mbed_enum_flags.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_stats.h mbed_thread.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h SharedPtr.h SingletonPtr.h Span.h Stream.h Transaction.h
    ./mbed-os/storage/blockdevice/include/blockdevice/: BlockDevice.h BufferedBlockDevice.h ChainingBlockDevice.h ExhaustibleBlockDevice.h FlashSimBlockDevice.h HeapBlockDevice.h MBRBlockDevice.h ObservingBlockDevice.h ProfilingBlockDevice.h ReadOnlyBlockDevice.h SlicingBlockDevice.h
    ./mbed-os/storage/blockdevice/source/: BufferedBlockDevice.cpp ChainingBlockDevice.cpp ExhaustibleBlockDevice.cpp FlashSimBlockDevice.cpp HeapBlockDevice.cpp MBRBlockDevice.cpp ObservingBlockDevice.cpp ProfilingBlockDevice.cpp ReadOnlyBlockDevice.cpp SFDP.cpp SlicingBlockDevice.cpp
    ./mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/TARGET_STM32G431xB/: cmsis_nvic.h system_clock.c
    ./mbed-os/rtos/source/: ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp rtos_handlers.h rtos_idle.h Semaphore.cpp ThisThread.cpp Thread.cpp
    ./mbed-os/rtos/include/rtos/: ConditionVariable.h EventFlags.h Kernel.h Mail.h mbed_rtos_types.h MemoryPool.h Mutex.h Queue.h rtos.h Semaphore.h ThisThread.h Thread.h
    ./mbed-os/platform/include/platform/internal/: CThunkBase.h mbed_atomic_impl.h mbed_error_hist.h mbed_fault_handler.h mbed_os_timer.h SysTimer.h
    ./mbed-os/platform/source/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    ./mbed-os/drivers/include/drivers/interfaces/: InterfaceCAN.h InterfaceDigitalIn.h InterfaceDigitalInOut.h InterfaceDigitalOut.h
    ./mbed-os/hal/source/: LowPowerTickerWrapper.cpp mbed_compat.c mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_gpio_irq.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_pinmap_common.c mbed_pinmap_default.cpp mbed_ticker_api.c mbed_us_ticker_api.c static_pinmap.cpp
    ./mbed-os/: mbed.h
    ./mbed-os/cmsis/device/: mbed_cmsis_conf.h
    ./mbed-os/platform/source/TARGET_CORTEX_M/: mbed_fault_handler.c
    ./mbed-os/features/frameworks/mbed-greentea-io/: mbed_io.cpp
    ./mbed-os/hal/source/mpu/: mbed_mpu_v7m.c mbed_mpu_v8m.c
    ./mbed-os/platform/source/minimal-printf/: mbed_printf_armlink_overrides.c mbed_printf_implementation.c mbed_printf_implementation.h mbed_printf_wrapper.c
    ./mbed-os/rtos/include/rtos/internal/: mbed_rtos1_types.h mbed_rtos_storage.h
    ./mbed-os/platform/mbed-trace/source/: mbed_trace.c
    ./mbed-os/platform/mbed-trace/include/mbed-trace/: mbed_trace.h ns_trace.h
    ./mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Source/: mbed_tz_context.c
    ./mbed-os/hal/usb/source/: mbed_usb_phy.cpp
    ./mbed-os/platform/cxxsupport/: mstd_mutex.cpp
    ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/TARGET_STM32G431xB/TARGET_NUCLEO_G431KB/: PeripheralPins.c PinNames.h
    ./mbed-os/cmsis/device/RTE/include/: RTE_Components.h
    ./mbed-os/storage/blockdevice/include/blockdevice/internal/: SFDP.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/TARGET_STM32G431xB/TOOLCHAIN_ARM/: startup_stm32g431xx.S
    ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/STM32Cube_FW/STM32G4xx_HAL_Driver/Legacy/: stm32_hal_legacy.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/STM32Cube_FW/CMSIS/: stm32g431xx.h stm32g441xx.h stm32g471xx.h stm32g473xx.h stm32g474xx.h stm32g483xx.h stm32g484xx.h stm32g491xx.h stm32g4a1xx.h stm32g4xx.h stm32gbk1cb.h system_stm32g4xx.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/STM32Cube_FW/STM32G4xx_HAL_Driver/: stm32g4xx_hal.c stm32g4xx_hal.h stm32g4xx_hal_adc.c stm32g4xx_hal_adc.h stm32g4xx_hal_adc_ex.c stm32g4xx_hal_adc_ex.h stm32g4xx_hal_comp.c stm32g4xx_hal_comp.h stm32g4xx_hal_cordic.c stm32g4xx_hal_cordic.h stm32g4xx_hal_cortex.c stm32g4xx_hal_cortex.h stm32g4xx_hal_crc.c stm32g4xx_hal_crc.h stm32g4xx_hal_crc_ex.c stm32g4xx_hal_crc_ex.h stm32g4xx_hal_cryp.c stm32g4xx_hal_cryp.h stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_cryp_ex.h stm32g4xx_hal_dac.c stm32g4xx_hal_dac.h stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dac_ex.h stm32g4xx_hal_def.h stm32g4xx_hal_dma.c stm32g4xx_hal_dma.h stm32g4xx_hal_dma_ex.c stm32g4xx_hal_dma_ex.h stm32g4xx_hal_exti.c stm32g4xx_hal_exti.h stm32g4xx_hal_fdcan.c stm32g4xx_hal_fdcan.h stm32g4xx_hal_flash.c stm32g4xx_hal_flash.h stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ex.h stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_flash_ramfunc.h stm32g4xx_hal_fmac.c stm32g4xx_hal_fmac.h stm32g4xx_hal_gpio.c stm32g4xx_hal_gpio.h stm32g4xx_hal_gpio_ex.h stm32g4xx_hal_hrtim.c stm32g4xx_hal_hrtim.h stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c.h stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_i2c_ex.h stm32g4xx_hal_i2s.c stm32g4xx_hal_i2s.h stm32g4xx_hal_irda.c stm32g4xx_hal_irda.h stm32g4xx_hal_irda_ex.h stm32g4xx_hal_iwdg.c stm32g4xx_hal_iwdg.h stm32g4xx_hal_lptim.c stm32g4xx_hal_lptim.h stm32g4xx_hal_nand.c stm32g4xx_hal_nand.h stm32g4xx_hal_nor.c stm32g4xx_hal_nor.h stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp.h stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_opamp_ex.h stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd.h stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pcd_ex.h stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr.h stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_pwr_ex.h stm32g4xx_hal_qspi.c stm32g4xx_hal_qspi.h stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc.h stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rcc_ex.h stm32g4xx_hal_rng.c stm32g4xx_hal_rng.h stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc.h stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_rtc_ex.h stm32g4xx_hal_sai.c stm32g4xx_hal_sai.h stm32g4xx_hal_sai_ex.c stm32g4xx_hal_sai_ex.h stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard.h stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_smartcard_ex.h stm32g4xx_hal_smbus.c stm32g4xx_hal_smbus.h stm32g4xx_hal_smbus_ex.c stm32g4xx_hal_smbus_ex.h stm32g4xx_hal_spi.c stm32g4xx_hal_spi.h stm32g4xx_hal_spi_ex.c stm32g4xx_hal_spi_ex.h stm32g4xx_hal_sram.c stm32g4xx_hal_sram.h stm32g4xx_hal_tim.c stm32g4xx_hal_tim.h stm32g4xx_hal_tim_ex.c stm32g4xx_hal_tim_ex.h stm32g4xx_hal_uart.c stm32g4xx_hal_uart.h stm32g4xx_hal_uart_ex.c stm32g4xx_hal_uart_ex.h stm32g4xx_hal_usart.c stm32g4xx_hal_usart.h stm32g4xx_hal_usart_ex.c stm32g4xx_hal_usart_ex.h stm32g4xx_hal_wwdg.c stm32g4xx_hal_wwdg.h stm32g4xx_ll_adc.c stm32g4xx_ll_adc.h stm32g4xx_ll_bus.h stm32g4xx_ll_comp.c stm32g4xx_ll_comp.h stm32g4xx_ll_cordic.c stm32g4xx_ll_cordic.h stm32g4xx_ll_cortex.h stm32g4xx_ll_crc.c stm32g4xx_ll_crc.h stm32g4xx_ll_crs.c stm32g4xx_ll_crs.h stm32g4xx_ll_dac.c stm32g4xx_ll_dac.h stm32g4xx_ll_dma.c stm32g4xx_ll_dma.h stm32g4xx_ll_dmamux.h stm32g4xx_ll_exti.c stm32g4xx_ll_exti.h stm32g4xx_ll_fmac.c stm32g4xx_ll_fmac.h stm32g4xx_ll_fmc.c stm32g4xx_ll_fmc.h stm32g4xx_ll_gpio.c stm32g4xx_ll_gpio.h stm32g4xx_ll_hrtim.c stm32g4xx_ll_hrtim.h stm32g4xx_ll_i2c.c stm32g4xx_ll_i2c.h stm32g4xx_ll_iwdg.h stm32g4xx_ll_lptim.c stm32g4xx_ll_lptim.h stm32g4xx_ll_lpuart.c stm32g4xx_ll_lpuart.h stm32g4xx_ll_opamp.c stm32g4xx_ll_opamp.h stm32g4xx_ll_pwr.c stm32g4xx_ll_pwr.h stm32g4xx_ll_rcc.c stm32g4xx_ll_rcc.h stm32g4xx_ll_rng.c stm32g4xx_ll_rng.h stm32g4xx_ll_rtc.c stm32g4xx_ll_rtc.h stm32g4xx_ll_spi.c stm32g4xx_ll_spi.h stm32g4xx_ll_system.h stm32g4xx_ll_tim.c stm32g4xx_ll_tim.h stm32g4xx_ll_ucpd.c stm32g4xx_ll_ucpd.h stm32g4xx_ll_usart.c stm32g4xx_ll_usart.h stm32g4xx_ll_usb.c stm32g4xx_ll_usb.h stm32g4xx_ll_utils.c stm32g4xx_ll_utils.h stm32g4xx_ll_wwdg.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32G4/STM32Cube_FW/: stm32g4xx_hal_conf.h system_stm32g4xx.c
    ./mbed-os/hal/usb/include/usb/: usb_phy_api.h USBPhy.h USBPhyEvents.h USBPhyTypes.h
